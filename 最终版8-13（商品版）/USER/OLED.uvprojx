# Keil uVision project OLED.uvprojx, settings and files
target Init (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OLED +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\SYSTEM\BEEP;..\SYSTEM\key;..\SYSTEM\led;..\SYSTEM\oled;..\HARDWARE\RM_DBUS;..\HARDWARE\PWM;..\HARDWARE\Encoder;..\SYSTEM\timer;..\SYSTEM;..\HARDWARE\MPU6050;..\SYSTEM\IIC_sw;..\SYSTEM\my_math;..\HARDWARE\IMU;..\HARDWARE\Pixy;..\HARDWARE\BLDC;..\HARDWARE\Servo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c scheduler.c Kalman.c Control.c fuzzy.h
    ../HARDWARE/: fuzzy.c
  group HARDWARE
    ../HARDWARE/RM_DBUS/: DJI_RC.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/Encoder/: Encoder.c
    ../HARDWARE/MPU6050/: MPU6050.c
    ../HARDWARE/IMU/: imu.c
    ../HARDWARE/Pixy/: Pixy.c
    ../HARDWARE/BLDC/: BLDC.c
    ../HARDWARE/Servo/: servo.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c data_transfer.c
    ../SYSTEM/BEEP/: beep.c
    ../SYSTEM/key/: key.c
    ../SYSTEM/led/: led.c
    ../SYSTEM/oled/: oled.c
    ../SYSTEM/timer/: timer.c
    ../SYSTEM/: GPIO_Test.c
    ../SYSTEM/IIC_sw/: IIC_sw.c
    ../SYSTEM/my_math/: mymath.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_syscfg.c
  group README
    ../: readme.txt
